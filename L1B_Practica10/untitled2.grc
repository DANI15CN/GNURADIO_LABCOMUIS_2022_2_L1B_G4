options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: multiplexaPAM
    output_language: python
    title: multiplexaPAM
  states: {}

blocks:
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: D
  id: variable_qtgui_range
  parameters:
    label: Ancho pulso
    rangeType: int
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: D1
  id: variable_qtgui_range
  parameters:
    label: Retardo 1
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: D2
  id: variable_qtgui_range
  parameters:
    label: Retardo 2
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: D3
  id: variable_qtgui_range
  parameters:
    label: Retardo 3
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: Df
  id: variable_qtgui_range
  parameters:
    label: desmdulador
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia mensaje
    start: '0'
    step: '10'
    stop: '10000'
    value: '100'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: Frecuencia pulsos
    start: '0'
    step: '1'
    stop: '10000'
    value: '2000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: D1
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: D2
    type: float
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: D3
    type: float
  states: {}
- name: blocks_delay_0_0_1
  id: blocks_delay
  parameters:
    delay: Df
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: modulaciondepulsos_0
  id: modulaciondepulsos
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: modulaciondepulsos_0_0
  id: modulaciondepulsos
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: modulaciondepulsos_0_0_0
  id: modulaciondepulsos
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: modulaciondepulsos_0_0_0_0
  id: modulaciondepulsos
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: modulaciondepulsos_0_0_0_0_0
  id: modulaciondepulsos
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '5'
    size: '4096'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 50e6
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', modulaciondepulsos_0, '0']
- [analog_sig_source_x_0_0, '0', modulaciondepulsos_0_0, '0']
- [analog_sig_source_x_0_0_0, '0', modulaciondepulsos_0_0_0, '0']
- [analog_sig_source_x_0_0_0_0, '0', modulaciondepulsos_0_0_0_0, '0']
- [blocks_add_xx_0, '0', blocks_delay_0_0_1, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '4']
- [blocks_delay_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0_0, '0', blocks_add_xx_0, '2']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_0_0_0, '0', blocks_add_xx_0, '3']
- [blocks_delay_0_0_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_delay_0_0_1, '0', modulaciondepulsos_0_0_0_0_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [modulaciondepulsos_0, '0', blocks_add_xx_0, '0']
- [modulaciondepulsos_0, '0', qtgui_time_sink_x_0, '0']
- [modulaciondepulsos_0_0, '0', blocks_delay_0, '0']
- [modulaciondepulsos_0_0_0, '0', blocks_delay_0_0, '0']
- [modulaciondepulsos_0_0_0_0, '0', blocks_delay_0_0_0, '0']
- [modulaciondepulsos_0_0_0_0_0, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
